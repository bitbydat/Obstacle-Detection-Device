# Keil uVision project Obstacle_Detection_Device.uvprojx, settings and files
target Device (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Re_stick +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\inc;.\FreeRTOS-Kernel\include;.\FreeRTOS-Kernel\portable\RVDS\ARM_CM3
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group src
    ./: systick_time.c gp_drive.c timer_drive.c uart_drive.c main.c button.c esp32.c a7680c.c DFplayer.c gps.c ultrasonic.c
    ./inc/: allheader.h
  group freeRTOS
    ./: heap_2.c list.c port.c queue.c tasks.c timers.c
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0
